# Keil uVision project GongChuangSai.uvprojx, settings and files
target GongChuangSai (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GongChuangSai +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Config;../Control;../App;../Hardware;../IMU20948/inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Control
    ../Control/: mecanum_chassis.c mecanum_chassis.h Motor.c Motor.h nav.c nav.h
  group App
    ../App/: app_pid_test.c app_runtime.c app_runtime.h app_race.c app_race.h race_fsm.c race_fsm.h race_task_plan.c race_task_plan.h race_ui.c race_ui.h app_ring_align.c app_ring_align.h app_pick_fsm.c app_pick_fsm.h app_pick_motion.c app_pick_motion.h app_servo_key.c app_servo_key.h app_square.c app_square.h app_stepper_openloop.c app_stepper_openloop.h display_nav.c display_nav.h
  group Hardware
    ../Hardware/: oledfont.h bsp_oled.c bsp_oled.h app_imu.c app_imu.h bsp_stepper.c bsp_vbat.c app_stepper_drive.c bsp_ulog.c bsp_ulog.h bsp_stepper.h bsp_d36_cmd.c bsp_d36_cmd.h bsp_servo.c bsp_servo.h bsp_uart_router.c vision.c vision.h
    ../Config/: app_mode.h race_config.h stepper_config.h
  group IMU20948
    ../IMU20948/src/: icm20948.c imu_attitude.c
    ../IMU20948/port/: imu_port_stm32_hal.c
target PID_Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: PID_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_RUN_MODE=4,APP_PID_TEST_ENABLE=1,MOTOR_TUNE=0,APP_D36_UART_CMD_ENABLE=0
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group added to the first target's files
    ../App/: app_pid_test.h
software components: CMSIS:CORE 4.3.0
